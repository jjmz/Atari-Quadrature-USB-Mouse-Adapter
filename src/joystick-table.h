// PID/VID -> Swap Bytes

#define DEFAULT_JOYSTICK                0x00,0x00,0x00,0x00,	\
								        0x11,0x40,0x21,0xC0,	\
										0x10,0x40,0x20,0xC0,	\
										0x33,0xFF,0xFF,0xFF,	\
										0xFF,0xFF,0xFF,0xFF,	

// VID-PID : 0079-0006
#define TWINSHOCK				        0x79,0x00,0x06,0x00,	\
								        0x11,0x40,0x21,0xC0,	\
										0x10,0x40,0x20,0xC0,	\
										0x36,0xFF,0xFF,0xFF,	\
										0xFF,0xFF,0xFF,0xFF,

// VID-PID : 2DC8-6001
#define EIGHTBITDO_SN30			        0xC8,0x2D,0x01,0x60,	\
								        0x14,0x40,0x24,0xC0,	\
										0x13,0x40,0x23,0xC0,	\
										0x30,0xFF,0xFF,0xFF,	\
										0xFF,0xFF,0xFF,0xFF,				

// VID-PID : 044F-B315
#define THRUSTMASTER			        0x4F,0x04,0x15,0xB3,	\
								        0x44,0xC0,0x54,0x40,	\
										0x43,0xC0,0x53,0x40,	\
										0x30,0xFF,0xFF,0xFF,	\
										0xFF,0xFF,0xFF,0xFF,	

#define PADCEDRIC						0x79,0x00,0x11,0x00,	\
										0x14,0x40,0x24,0xC0,	\
										0x13,0x40,0x23,0xC0,	\
										0x35,0x60,0xFF,0xFF,	\
										0xFF,0xFF,0xFF,0xFF,

#define EMPTY                           0xFF,0xFF,0xFF,0xFF,  \
                                        0xFF,0xFF,0xFF,0xFF,  \
                                        0xFF,0xFF,0xFF,0xFF,  \
                                        0xFF,0xFF,0xFF,0xFF,  \
                                        0xFF,0xFF,0xFF,0xFF,                                                                                

uint8_t cpval;

uint8_t cond_set_io(uint8_t idx)
{
	uint8_t rxval=RxBuffer[idx&0xF];
	switch (idx>>4)
     {   case 0x0:
	      if (rxval==cpval) return 0; else return 1;
		 case 0x1:
	      if (rxval<cpval) return 0; else return 1;
	    case 0x2:
		  if (rxval>cpval) return 0; else return 1;
		case 0x3:
		  if (rxval&cpval) return 0; else return 1;
		case 0x4:
		  if ((int8_t)rxval<(int8_t)cpval) return 0; else return 1;
		case 0x5:
		  if ((int8_t)rxval>(int8_t)cpval) return 0; else return 1;
	 }
	 return 0xFF;
}